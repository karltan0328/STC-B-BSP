# Keil uVision project without_bsp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: without_bsp +hex
  c flags: Optimize=8 SizeSpeed=1
  group adc
    ./src/: karl_adc.c karl_adc.h
  group beep
    ./src/: karl_beep.c karl_beep.h
  group callback
    ./src/: karl_callback.c karl_callback.h
  group displayer
    ./src/: karl_displayer.c karl_displayer.h
  group key
    ./src/: karl_key.c karl_key.h
  group stepmotor
    ./src/: karl_stepmotor.c karl_stepmotor.h
  group timer0
    ./src/: karl_timer0.c karl_timer0.h
  group timer1
    ./src/: karl_timer1.c karl_timer1.h
  group main
    ./src/: main.c
  group STC
    ./src/: STC15F2K60S2.h
